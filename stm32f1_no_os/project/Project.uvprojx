# Keil uVision project Project.uvprojx, settings and files
target _24cxx_demo (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\source\application;..\source\comm;..\Source\hardware;..\source\drivers;..\Source\stm32lib\inc;..\Source\stm32lib\startup;..\Source\stm32lib\conf;..\source\comm;..\Source\stepmotor;..\source\components\drivers;..\..\components
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group include
    ../source/application/: main.h
  group application
    ../source/application/: board.c main.c
  group component
    ../../components/: _24cxx_dev.c i2c_bitops.c i2c_core.c
  group driver
    ../source/drivers/: at24cxx.c fm24clxx.c i2c_hw.c
  group hardware
    ../Source/hardware/: time.c nvic.c
    ../source/hardware/: systick_delay.c stm32f10x_it.c
  group stm32Lib
    ../Source/stm32lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Source/stm32lib/startup/: core_cm3.c startup_stm32f10x_hd.s
    ../Source/stm32lib/conf/: system_stm32f10x.c
  group read
    ../Read/: version.txt
